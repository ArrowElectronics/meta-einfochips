
EXTRA_OECMAKE += " -DENABLE_NEON=ON "
