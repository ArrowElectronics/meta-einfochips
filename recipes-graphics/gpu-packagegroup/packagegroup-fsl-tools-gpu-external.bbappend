VULKAN_TOOLS_remove_mx8   = " vkmark"
