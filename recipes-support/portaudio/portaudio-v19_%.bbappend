FILESEXTRAPATHS_prepend := "${THISDIR}/files:"


SRC_URI_append += " file://0001-Set-default-sampling-rate-to-48k.patch "
