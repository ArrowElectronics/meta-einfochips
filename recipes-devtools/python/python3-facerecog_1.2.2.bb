inherit pypi setuptools3
require python-facerecog.inc
