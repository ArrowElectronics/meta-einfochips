inherit pypi setuptools3
require python-ipython.inc
