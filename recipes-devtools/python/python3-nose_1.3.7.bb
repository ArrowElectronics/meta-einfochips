inherit pypi setuptools3
require python-nose.inc
