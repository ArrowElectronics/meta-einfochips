inherit pypi setuptools
require python-eyed3.inc
