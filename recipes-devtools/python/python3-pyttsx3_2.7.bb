inherit pypi setuptools3
require python-pyttsx3.inc
