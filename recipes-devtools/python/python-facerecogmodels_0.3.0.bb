inherit pypi setuptools
require python-facerecogmodels.inc
