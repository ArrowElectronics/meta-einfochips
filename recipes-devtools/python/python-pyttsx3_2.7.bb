inherit pypi setuptools
require python-pyttsx3.inc
