inherit pypi setuptools3
require python-facerecogmodels.inc
