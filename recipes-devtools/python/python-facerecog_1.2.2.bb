inherit pypi setuptools
require python-facerecog.inc
