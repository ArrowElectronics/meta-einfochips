inherit pypi setuptools
require python-pydub.inc
