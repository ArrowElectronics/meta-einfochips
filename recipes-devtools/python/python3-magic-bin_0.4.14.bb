inherit setuptools3
require python-magic-bin.inc
