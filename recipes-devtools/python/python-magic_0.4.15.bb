inherit pypi setuptools
require python-magic.inc
