inherit setuptools3
require python-pyaudio.inc
