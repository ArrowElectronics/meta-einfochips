inherit pypi setuptools
require python-ipython.inc
