inherit pypi setuptools
require python-pyaudio.inc
