inherit setuptools
require python-magic-bin.inc
