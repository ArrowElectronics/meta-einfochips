inherit pypi setuptools3
require python-eyed3.inc
