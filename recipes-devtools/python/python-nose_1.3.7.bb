inherit pypi setuptools
require python-nose.inc
